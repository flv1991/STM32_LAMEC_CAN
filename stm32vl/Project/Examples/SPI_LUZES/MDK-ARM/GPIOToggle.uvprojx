# Keil uVision project GPIOToggle.uvprojx, settings and files
target GPIOToggle (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F100VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIOToggle
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_MD_VL, USE_STDPERIPH_DRIVER
  c include: ..\;..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\..\Utilities\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c tm_stm32f4_fonts.c tm_stm32f4_ili9341.c stm32f10x_spi.c stm32f10x_tim.c
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/inc/: tm_stm32f4_fonts.h tm_stm32f4_ili9341.h stm32f10x_tim.h
  group CMSIS
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md_vl.s
  group Doc
    ../: readme.txt
  group User
    ../: main.c stm32f10x_it.c defines.h
  group STM32vldiscovery
    ../../../../Utilities/: STM32vldiscovery.c
software components: CMSIS:CORE 4.2.0
